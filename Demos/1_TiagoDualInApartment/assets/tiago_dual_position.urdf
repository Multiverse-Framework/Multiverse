Commit message: Update

File: Demos/1_TiagoDualInApartment/assets/tiago_dual_position.urdf (robot description, URDF)
Before this commit: robot tiago_dual, 26 links, 25 joints
Links:
- link base_link: mass 59.53853988647461 -> None
