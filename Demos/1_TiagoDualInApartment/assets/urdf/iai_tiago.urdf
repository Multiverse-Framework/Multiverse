Commit message: Finish demo

File: Demos/1_TiagoDualInApartment/assets/urdf/iai_tiago.urdf (robot description, URDF)
Before this commit: robot base_footprint, 68 links, 67 joints
Links:
- link base_footprint: mass 68.70663452148438 -> None; geometry 
